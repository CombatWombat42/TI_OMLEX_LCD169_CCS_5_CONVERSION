<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430_169LCD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


